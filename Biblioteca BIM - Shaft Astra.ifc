Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-07-10T16:27:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - IU alternativa 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 10 16:27:14 2025 * Host: DNG1464 * Database: C:\Users\maria.cardoso\AppData\Local\Temp\5ce26899-2bf9-4bf3-98c8-0b4f1d6c47b1\55220509-25f8-4d56-87c7-9c2ec88f5881\ifc * Database version: 5507 * Database creation date: Thu Jul 10 16:26:58 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 10 16:26:58 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 10 16:26:58 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Vista Principal
LongName: Vista Principal; Elevation: 0 mm

# IfcBuildingElementProxy: Texto do modelo:600mm Arial, Texto do modelo:600mm Arial:334168
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: 600mm Arial
Type - Pset_QuantityTakeOff - Reference: 600mm Arial
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texto do modelo:MODELO DE TEXTO 2 (12)
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: MODELO DE TEXTO 2
Type - Pset_QuantityTakeOff - Reference: MODELO DE TEXTO 2
Pset_BuildingElementProxyCommon - sets with these values: 2
Name (Texto do modelo:MODELO DE TEXTO 2:...)
334246
334265
337136
337189
337203
337224
337242
337315
337383
337696
337771
338606

# IfcBuildingElementProxy: Texto do modelo:MODELO DE TEXTO 3, Texto do modelo:MODELO DE TEXTO 3:334039
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: MODELO DE TEXTO 3
Type - Pset_QuantityTakeOff - Reference: MODELO DE TEXTO 3
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcFlowTerminal: SH135_V:Shaft 213x413x36mm - Vácuo Formada - Parafuso - Visita - Ventilado, SH135_V:Shaft 213x413x36mm - Vácuo Formada - Parafuso - Visita - Ventilado:333965
In: Vista Principal
Type - Pset_ManufacturerTypeInformation - Manufacturer: ASTRA
Type - Pset_QuantityTakeOff - Reference: Shaft 213x413x36mm - Vácuo Formada - Parafuso - Visita - Ventilado
Pset_DistributionFlowElementCommon - Reference: Shaft 213x413x36mm - Vácuo Formada - Parafuso - Visita - Ventilado; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: SH22C_1:Shaft 180x220x20mm - Vacuo Formada - Parafuso - Visita, SH22C_1:Shaft 180x220x20mm - Vacuo Formada - Parafuso - Visita:329864
In: Vista Principal
Type - Pset_ManufacturerTypeInformation - Manufacturer: ASTRA
Type - Pset_QuantityTakeOff - Reference: Shaft 180x220x20mm - Vacuo Formada - Parafuso - Visita
Pset_DistributionFlowElementCommon - Reference: Shaft 180x220x20mm - Vacuo Formada - Parafuso - Visita; sets with these values: 2

# IfcFlowTerminal: SH30C_1:Shaft 250x300x19mm - Vauco Formada - Parafuso - Visita, SH30C_1:Shaft 250x300x19mm - Vauco Formada - Parafuso - Visita:330685
In: Vista Principal
Type - Pset_ManufacturerTypeInformation - Manufacturer: ASTRA
Type - Pset_QuantityTakeOff - Reference: Shaft 250x300x19mm - Vauco Formada - Parafuso - Visita
Pset_DistributionFlowElementCommon - Reference: Shaft 250x300x19mm - Vauco Formada - Parafuso - Visita; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: SH33C_1:Shaft 240x330x20mm - Vácuo Formado - Embutir - Visita, SH33C_1:Shaft 240x330x20mm - Vácuo Formado - Embutir - Visita:331505
In: Vista Principal
Type - Pset_ManufacturerTypeInformation - Manufacturer: ASTRA
Type - Pset_QuantityTakeOff - Reference: Shaft 240x330x20mm - Vácuo Formado - Embutir - Visita
Pset_DistributionFlowElementCommon - Reference: Shaft 240x330x20mm - Vácuo Formado - Embutir - Visita; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: SH46_C:Shaft 465x465x35mm - Vácuo Formada - Embutido - Visita - Ventilado, SH46_C:Shaft 465x465x35mm - Vácuo Formada - Embutido - Visita - Ventilado:332325
In: Vista Principal
Type - Pset_ManufacturerTypeInformation - Manufacturer: ASTRA
Type - Pset_QuantityTakeOff - Reference: Shaft 465x465x35mm - Vácuo Formada - Embutido - Visita - Ventilado
Pset_DistributionFlowElementCommon - Reference: Shaft 465x465x35mm - Vácuo Formada - Embutido - Visita - Ventilado; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: SH50C:Shaft 356x496x28mm - Vácuo Formada - Parafuso - Visita, SH50C:Shaft 356x496x28mm - Vácuo Formada - Parafuso - Visita:333145
In: Vista Principal
Type - Pset_ManufacturerTypeInformation - Manufacturer: ASTRA
Type - Pset_QuantityTakeOff - Reference: Shaft 356x496x28mm - Vácuo Formada - Parafuso - Visita
Pset_DistributionFlowElementCommon - Reference: Shaft 356x496x28mm - Vácuo Formada - Parafuso - Visita; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
